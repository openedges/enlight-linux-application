## npu_testapp/Kconfig
```kconfig
#
# TEST configuration
#

config TestDrv
    tristate "TEST TEST"

if TestDrv

menu "Test drivers"

endmenu

endif
```
